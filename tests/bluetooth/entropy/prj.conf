## prj.conf
```kconfig
CONFIG_BT=y
CONFIG_BT_HCI_RAW=y
CONFIG_ENTROPY_GENERATOR=y
```

## src/main.c
```c
/* test case main entry */
void test_main(void)
{
}
```
