## tests/bluetooth/entropy/testcase.yaml
```yaml
tests:
  bluetooth.entropy:
    platform_allow: nrf5340dk_nrf5340_cpuapp
    tags: bluetooth host
```
